Commit message: add pendulum, only joint axis z works, still slow

File: torch_robotics/data/urdf/robots/pendulum/2_link_planar.urdf (robot description, URDF)
Before this commit: robot 3_link_planar, 5 links, 4 joints
Links:
- removed link link_ee
Joints:
- removed joint joint_ee
